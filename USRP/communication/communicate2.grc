options:
  parameters:
    author: Dy
    generate_options: qt_gui
    id: communicate2
    output_language: python
    title: communicate2
  states: {}

blocks:
- name: delay1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {}
- name: psk_8
  id: variable_constellation
  parameters:
    const_points: '[0.924+0.383j,0.383+0.924j,-0.383+0.924j,-0.924+0.383j,-0.924-0.383j,-0.383-0.924j,0.383-0.924j,0.924-0.383j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '8'
    sym_map: '[0, 1, 2,3,4,5,6,7]'
    type: calcdist
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.5'
    gain: '1.0'
    ntaps: '100'
    samp_rate: samp_rate
    sym_rate: symb_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: samp_rate / sps
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    rangeType: int
    start: '990000000'
    step: '10000000'
    stop: '1010000000'
    value: '1000000000'
  states: {}
- name: update
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,1
    label0: run
    label1: stop
    num_opts: '2'
    option0: '0.1'
    option1: '100'
    type: real
    value: '0.1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '20.0'
    max_gain: '65536'
    rate: '0.000005'
    reference: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay1
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_1_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/32768
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '3'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '3'
    l: '8'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (64,61)
    type: byte
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (1,1)
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (64,12,49)
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (7,7,7,7,0,1,2,3,4,5,6,7)
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: psk_8
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: psk_8
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: '0.0001'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '100'
    init_phase: '50'
    loop_bw: '0.000015'
    max_dev: '1'
    osps: '4'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: psk_8
    damping: '1'
    loop_bw: '0.001'
    max_dev: '1'
    nfilters: '100'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    GI_len: '45'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from collections import Counter

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, GI_len=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='change',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.GI_len = GI_len
              self.param = 0.0
              self.signal = np.zeros(self.GI_len, dtype=np.float32)

          def work(self, input_items, output_items):
              k = 0
              for i in input_items[0]:
                  k = k + 1
                  if k > 100 : break
                  count = 0
                  for j in self.signal:
                      if i == j : count = count + 1
                      else : break
                  self.signal = np.insert(self.signal, 0, i)
                  self.signal = np.delete(self.signal, self.GI_len) 
                  if count > self.GI_len*0.9 : 
                      self.param = i
                      break
              for i in range(0, len(input_items[0])) :
                  input_items[0][i] = input_items[0][i] - self.param
                  if(input_items[0][i] < 0): input_items[0][i] = input_items[0][i] + 8
              output_items[0][:] = input_items[0]
              return len(output_items[0])
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    name: '"rx"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    gui_hint: 1,2,1,1
    name: '"tx"'
    size: '1024'
    tr_level: '0'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    gui_hint: 2,1,1,1
    marker1: '0'
    name: '"rx"'
    size: '128'
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: update
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    gui_hint: 2,2,1,1
    marker1: '0'
    name: '"tx"'
    size: '128'
    srate: samp_rate
    tr_level: '0'
    type: float
    update_time: update
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    gui_hint: 0,2,1,1
    marker1: '0'
    name: '"rx_audio"'
    size: '512'
    srate: '48000'
    tr_level: '0.01'
    type: float
    update_time: update
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    gui_hint: 0,1,1,1
    marker1: '0'
    name: '"tx_audio"'
    size: '512'
    srate: '48000'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: update
  states: {}
- name: root_raised_cosine_filter_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '4'
    interp: sps
    ntaps: '100'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: interp_fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '500000'
    center_freq0: tx_freq
    dev_addr: '"serial=180009"'
    gain0: '75'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '500000'
    center_freq0: tx_freq
    dc_offs_enb0: disabled
    dev_addr: '"serial=180007"'
    gain0: '30'
    iq_imbal_enb0: disabled
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_3_1, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_1_1_0, '0']
- [blocks_char_to_float_0, '0', epy_block_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', blocks_multiply_const_vxx_3_2_1, '0']
- [blocks_char_to_float_1_0, '0', blocks_multiply_const_vxx_3_3, '0']
- [blocks_delay_0_0, '0', blocks_stream_demux_0, '0']
- [blocks_float_to_char_0, '0', blocks_delay_0_0, '0']
- [blocks_float_to_char_1, '0', blocks_stream_mux_0_0, '0']
- [blocks_float_to_char_1_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_float_to_short_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_const_vxx_3_0, '0', blocks_float_to_short_0_0, '0']
- [blocks_multiply_const_vxx_3_1, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_3_2, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_const_vxx_3_2_0, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_3_2_1, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_3_3, '0', blocks_add_xx_1, '1']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '2']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_stream_demux_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_3_2, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_3_2_0, '0']
- [blocks_stream_demux_0, '0', blocks_char_to_float_0_2, '0']
- [blocks_stream_demux_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [blocks_stream_demux_0, '1', blocks_null_sink_0, '0']
- [blocks_stream_demux_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_stream_demux_0_0, '1', blocks_char_to_float_1_0, '0']
- [blocks_stream_mux_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_stream_mux_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_stream_mux_0_0, '0', virtual_sink_1, '0']
- [blocks_sub_xx_0_0, '0', blocks_float_to_char_1, '0']
- [blocks_sub_xx_0_0_0, '0', blocks_float_to_char_1_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '1']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', blocks_float_to_char_0, '0']
- [root_raised_cosine_filter_0_1, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1, '0', blocks_repack_bits_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
